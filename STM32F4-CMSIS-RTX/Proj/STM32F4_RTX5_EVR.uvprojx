# Keil uVision project STM32F4_RTX5_EVR.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F417ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_RTX5_EVR +hex
  AfterMake: ..\Release\build.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HSE_VALUE=24000000U,STM32F417xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,_RTE_,DCB=CoreDebug,DCB_DEMCR_TRCENA_Msk=CoreDebug_DEMCR_TRCENA_Msk,DEBUG=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\Firmware\H_Files;..\Driver\H_Files;..\CsiLib\H_Files;..\Startup\H_Files;..\CMSIS\Core\Include;..\CMSIS\Core\Include\m-profile;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\Inc;..\CMSIS-ARM\CMSIS_6\CMSIS\RTOS2\Include;..\CMSIS-ARM\CMSIS_6\CMSIS\Driver\Include;..\CMSIS-ARM\CMSIS-RTX\Config;..\CMSIS-ARM\CMSIS-RTX\Include;..\CMSIS-ARM\CMSIS-RTE
  asm define: DEBUG=1
  asm include: ..\CMSIS-ARM\CMSIS-RTX\Config;..\CMSIS-ARM\CMSIS-RTX\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Firmware
    ../Firmware/C_Files/: main.c Initial.c Interrupt.c
  group Driver
    ../Driver/C_Files/: driver_data.c driver_gpio.c driver_iwdg.c driver_printf.c
  group CsiLib
    ../CsiLib/H_Files/: lib_defs.h lib_types.h
  group Startup
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f417xx.s
    ../Startup/C_Files/: stm32f4xx_it.c system_stm32f4xx.c HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Stm32Lib
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_rtc_alarm_template.c stm32f4xx_hal_timebase_rtc_wakeup_template.c stm32f4xx_hal_timebase_tim_template.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group CMSIS-Compiler
    ../CMSIS-ARM/CMSIS-Compiler/source/armcc/: retarget_io.c
    ../CMSIS-ARM/CMSIS-Compiler/source/: stderr_evr.c stdout_evr.c
    ../CMSIS-ARM/CMSIS-Compiler/template/stdio/: stderr_user.c stdin_user.c stdout_user.c
  group CMSIS-View
    ../CMSIS-ARM/CMSIS-View/EventRecorder/Source/: EventRecorder.c
    ../CMSIS-ARM/CMSIS-View/EventRecorder/Include/: EventRecorder.h
    ../CMSIS-ARM/CMSIS-View/EventRecorder/Config/: EventRecorderConf.h
  group RL-RTX/Source
    ../CMSIS-ARM/CMSIS-RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../CMSIS-ARM/CMSIS_6/CMSIS/RTOS2/Source/: os_systick.c os_tick_gtim.c os_tick_ptim.c os_tick_stim.c
    ../CMSIS-ARM/CMSIS-RTX/Config/: RTX_Config.c RTX_Config.h
  group RL-RTX/Ports
    ../CMSIS-ARM/CMSIS-RTX/Source/GCC/: irq_armv7m.S
target Target 2 (6220000::V6.22::ARMCLANG)
  device: STM32F417ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: as above
  output: STM32F4_RTX5_EVR +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HSE_VALUE=24000000U,STM32F417xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,_RTE_,DEBUG=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\Firmware\H_Files;..\Driver\H_Files;..\CsiLib\H_Files;..\Startup\H_Files;..\CMSIS\Core\Include;..\CMSIS\Core\Include\m-profile;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\Inc;..\CMSIS-ARM\CMSIS_6\CMSIS\RTOS2\Include;..\CMSIS-ARM\CMSIS_6\CMSIS\Driver\Include;..\CMSIS-ARM\CMSIS-Compiler\include;..\CMSIS-ARM\CMSIS-View\EventRecorder\Config;..\CMSIS-ARM\CMSIS-View\EventRecorder\Include;..\CMSIS-ARM\CMSIS-RTX\Config;..\CMSIS-ARM\CMSIS-RTX\Include;..\CMSIS-ARM\CMSIS-RTE
  asm define: _RTE_,DEBUG=1
  asm include: ..\CMSIS-ARM\CMSIS-RTE;..\CMSIS-ARM\CMSIS-RTX\Config;..\CMSIS-ARM\CMSIS-RTX\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Script\STM32F4_RTX5_EVR.sct
